# IAR project OS3.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: ZB204 ZB204
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: AES_WAFER_ID; ZB206_CHIP; PROTOCOL_HRF
  ICCARM.CCIncludePath2: ; ..\..\app; ..\..\src\app; ..\..\maf\hrf\board\BSP; ..\..\maf\hrf\board\BSP\inc; ..\..\maf\hrf\board\BSP\OS\uCOS-III; ..\..\maf\hrf\GSMCU\CMSIS\Device\Include; ..\..\maf\hrf\GSMCU\CMSIS\Include; ..\..\maf\hrf\GSMCU\HAL_Driver\Inc; ..\..\ucosIII\uC-CPU; ..\..\ucosIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\ucosIII\uC-LIB; ..\..\ucosIII\uCOS-III\Source; ..\..\ucosIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\src; ..\..\src\app; ..\..\src\aps; ..\..\src\net; ..\..\src\bplc; ..\..\src\phy; ..\..\src\common; ..\..\src; ..\..\src\cco; ..\..\version; ..\..\config; ..\..\src\encry; $TOOLKIT_DIR$\CMSIS\Driver\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS3.bin
  ILINK.IlinkOutputFile: OS3.out
  ILINK.IlinkIcfFile: ..\..\icf\sram_size.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: AES_WAFER_ID; __DEBUG_MODE
  ICCARM.CCIncludePath2: ..\..\app; ..\..\src\app; ..\..\maf\hrf\board\BSP; ..\..\maf\hrf\board\BSP\inc; ..\..\maf\hrf\board\BSP\OS\uCOS-III; ..\..\maf\hrf\GSMCU\CMSIS\Device\Include; ..\..\maf\hrf\GSMCU\CMSIS\Include; ..\..\maf\hrf\GSMCU\HAL_Driver\Inc; ..\..\ucosIII\uC-CPU; ..\..\ucosIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\ucosIII\uC-LIB; ..\..\ucosIII\uCOS-III\Source; ..\..\ucosIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\src; ..\..\src\app; ..\..\src\aps; ..\..\src\net; ..\..\src\bplc; ..\..\src\phy; ..\..\src\common; ..\..\src; ..\..\src\cco; ..\..\version; ..\..\config; ..\..\src\encry; $TOOLKIT_DIR$\CMSIS\Driver\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  prebuild: ..\..\version\SyncRevision.bat
  group APP
    ../../app/: app.c app_cfg.h cpu_cfg.h os_app_hooks.c
    ../../: lib_cfg.h os_app_hooks.h os_cfg.h os_cfg_app.h
  group BOARD
    ./: board_cco_def.h
    ../../config/: System_inc.h
  group BOARD/Drivers/HAL_Driver/Inc
    ../../maf/hrf/GSMCU/HAL_Driver/Inc/: gsmcu_cmp_lvd.h gsmcu_crc.h gsmcu_dma.h gsmcu_flash.h gsmcu_hal.h gsmcu_iwdg.h GSMCU_M3.h gsmcu_m3_gpio.h gsmcu_m3_pit32.h gsmcu_m3_port.h gsmcu_m3_pwm.h gsmcu_m3_spi.h gsmcu_m3_usart.h gsmcu_scu.h gsmcu_ssp.h gsmcu_trng.h gsmcuxx_hal_def.h hal_crc.h RTE_Components.h RTE_Device.h system_GSMCU_M3.h system_ZB204.h ZB204.h
  group BOARD/Drivers/HAL_Driver/Src
    ../../maf/hrf/GSMCU/HAL_Driver/Src/: gsmcu_cmp_lvd.c gsmcu_cortex.c gsmcu_crc.c gsmcu_dma.c gsmcu_flash.c gsmcu_iwdg.c gsmcu_m3_gpio.c gsmcu_m3_pit32.c gsmcu_m3_port.c gsmcu_m3_pwm.c gsmcu_m3_spi.c gsmcu_m3_usart.c gsmcu_scu.c gsmcu_trng.c gsmcuxx_hal.c system_GSMCU_M3.c
  group BSP
    ../../maf/hrf/board/BSP/: apdma.h bps_debug.c bps_debug.h bps_flash.c bps_flash.h bps_led.c bps_led.h bps_port.c bps_port.h bps_timer.c bps_timer.h bps_uart.c bps_uart.h bps_zerocross.c bps_zerocross.h bsp.c bsp.h bsp_int.c bsp_wdg.c bsp_wdg.h cpu_bsp.c
  group BSP/IAR
    ../../maf/hrf/board/BSP/IAR/: cstartup.c
  group SRC
    ../../src/: protocol_includes.h
  group SRC/app
    ../../src/app/: init.c
  group SRC/aps
    ../../src/aps/: local_protocol.c
  group SRC/cco
    ../../src/cco/: alert.c Manager_link.c module_def.c PLC_AutoRelay.c PLM_2005.c PLM_AFN.c PLM_AFN_GD.c protocol_645.c protocol_69845.c public_func.c queue.c SHA1.c SHA1.h soft_check.c soft_check.h storage.c Uart_Link.c
  group SRC/common
    ../../src/common/: algorithm.c common_includes.c common_includes.h fsm.c list.c map.h rbtree.c rbtree.h timer.c tmr_call.c
  group SRC/encry
    ../../src/encry/: aes.c aes.h crypto.c crypto.h sha.c sha.h sm4.c sm4.h
  group SRC/net
    ../../src/net/: hplc_app_def.c hplc_app_def.h hplc_beacon.h hplc_channel_status.h hplc_data.h hplc_frame.h hplc_mac.h hplc_task.c
    ../../: MAC_zb206.a
  group SRC/phy
    ../../src/phy/: hplc_phy.c Hplc_phy.h hrf_phy.c hrf_phy.h phy_task.c
    ../../: phy_zb206.a
  group uC/CPU
    ../../ucosIII/uC-CPU/: cpu_core.c
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../ucosIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../ucosIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../ucosIII/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../ucosIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../ucosIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
