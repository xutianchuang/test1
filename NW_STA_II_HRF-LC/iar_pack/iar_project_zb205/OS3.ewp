# IAR project OS3.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: ZB204 ZB204
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: HPLC_CSG; NEW_TOPO; ZB205_CHIP; BLE_NET_ENABLE
  ICCARM.CCIncludePath2: ..\..\app; ..\..\src\app; ..\..\device\hrf\board; ..\..\device\hrf\board\BSP; ..\..\device\hrf\board\BSP\inc; ..\..\device\hrf\board\BSP\OS\uCOS-III; ..\..\device\hrf\GSMCU\CMSIS\Device\Include; ..\..\device\hrf\GSMCU\CMSIS\Include; ..\..\device\hrf\GSMCU\HAL_Driver\Inc; ..\..\ucosIII\uC-CPU; ..\..\ucosIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\ucosIII\uC-LIB; ..\..\ucosIII\uCOS-III\Source; ..\..\ucosIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\src; ..\..\src\app\inc; ..\..\src\aps\inc; ..\..\src\net\inc; ..\..\src\bplc; ..\..\src\phy; ..\..\src\common\inc; ..\..\src; ..\..\src\common\finsh\inc; ..\..\version; ..\..\config; $TOOLKIT_DIR$\CMSIS\Driver\Include; $TOOLKIT_DIR$\CMSIS\Core\Include; ..\..\src\lc_iot\sta\ble_net
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OS3.bin
  postbuild: "$TOOLKIT_DIR$\bin\ielfdumparm.exe" --all --source "$TARGET_PATH$" -o "disasm.txt"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\icf\sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: HPLC_CSG; __DEBUG_MODE; NEW_TOPO
  ICCARM.CCIncludePath2: ..\..\app; ..\..\src\app; ..\..\device\hrf\board; ..\..\device\hrf\board\BSP; ..\..\device\hrf\board\BSP\inc; ..\..\device\hrf\board\BSP\OS\uCOS-III; ..\..\device\hrf\GSMCU\CMSIS\Device\Include; ..\..\device\hrf\GSMCU\CMSIS\Include; ..\..\device\hrf\GSMCU\HAL_Driver\Inc; ..\..\ucosIII\uC-CPU; ..\..\ucosIII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\ucosIII\uC-LIB; ..\..\ucosIII\uCOS-III\Source; ..\..\ucosIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\src; ..\..\src\app\inc; ..\..\src\aps\inc; ..\..\src\net\inc; ..\..\src\bplc; ..\..\src\phy; ..\..\src\common\inc; ..\..\src; ..\..\src\common\finsh\inc; ..\..\version; ..\..\config; $TOOLKIT_DIR$\CMSIS\Driver\Include; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  AARM.ADefines: __DEBUG_MODE
  prebuild: ..\..\version\SyncRevision.bat
  group APP
    ../../app/: app.c app_cfg.h cpu_cfg.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
    ../../src/aps/src/: app_new_task.c
  group BOARD
    ../../config/: board_sta_def.h
  group BOARD/Drivers/HAL_Driver/Inc
    ../../device/hrf/GSMCU/HAL_Driver/Inc/: gsmcu_crc.h gsmcu_dma.h gsmcu_flash.h gsmcu_hal.h gsmcu_iwdg.h GSMCU_M3.h gsmcu_m3_gpio.h gsmcu_m3_pit32.h gsmcu_m3_port.h gsmcu_m3_pwm.h gsmcu_m3_spi.h gsmcu_m3_usart.h gsmcu_scu.h gsmcu_ssp.h gsmcu_trng.h gsmcuxx_hal_def.h hal_crc.h RTE_Components.h RTE_Device.h system_GSMCU_M3.h system_ZB204.h ZB204.h
  group BOARD/Drivers/HAL_Driver/Src
    ../../device/hrf/GSMCU/HAL_Driver/Src/: gsmcu_cmp_lvd.c gsmcu_cortex.c gsmcu_crc.c gsmcu_dma.c gsmcu_flash.c gsmcu_iwdg.c gsmcu_m3_gpio.c gsmcu_m3_pit32.c gsmcu_m3_port.c gsmcu_m3_pwm.c gsmcu_m3_spi.c gsmcu_m3_usart.c gsmcu_scu.c gsmcu_trng.c gsmcuxx_hal.c system_GSMCU_M3.c
  group BSP
    ../../device/hrf/board/BSP/: apdma.h bps_debug.c bps_debug.h bps_flash.c bps_flash.h bps_ir_uart.c bps_led.c bps_led.h bps_port.c bps_port.h bps_timer.c bps_timer.h bps_uart.c bps_uart.h bps_uart_lcip.c bps_uart_lcip.h bps_zerocross.c bps_zerocross.h bsp.c bsp.h bsp_int.c bsp_wdg.c bsp_wdg.h cpu_bsp.c
  group BSP/IAR
    ../../device/hrf/board/BSP/IAR/: cstartup.c
  group SRC
    ../../src/: protocol_includes.h
  group SRC/app
    ../../src/app/src/: debug_cmd.c init.c
  group SRC/app/inc
    ../../src/app/inc/: debug_cmd.h
    ../../src/aps/inc/: soft_check.h
  group SRC/aps
    ../../src/aps/src/: app_event_IIcai.c app_led_IIcai.c app_RF_IIcai.c app_search_meter.c applocal.c crclib.c lc_app.c lc_obj_model.c lc_whi_adapt.c lc_whi_group.c lc_whi_pro.c lc_whi_sysctrl.c lcip_applocal.c local_protocol.c PLM_2005.c stream_buffer.c
  group SRC/aps/inc
    ../../src/aps/inc/: applocal.h lcip_applocal.h local_protocol.h SHA1.h stream_buffer.h
  group SRC/common
    ../../src/common/src/: algorithm.c common_includes.c fsm.c list.c map.c rbtree.c task_call.c timer.c tmr_call.c
  group SRC/common/finsh
    ../../src/common/finsh/src/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c symbol.c
    ../../src/common/finsh/inc/: finsh_ops.h
  group SRC/common/finsh/inc
    ../../src/common/finsh/inc/: finsh.h finsh_api.h finsh_device.h finsh_error.h finsh_heap.h finsh_node.h finsh_parser.h finsh_token.h finsh_var.h finsh_vm.h msh.h rtconfig.h rtdef.h shell.h
  group SRC/common/inc
    ../../src/common/inc/: algorithm.h common_includes.h fsm.h list.h map.h rbtree.h task_call.h timer.h tmr_call.h
  group SRC/encry
    ../../src/encry/: aes.c aes.h crypto.c crypto.h sha.c sha.h sm4.c sm4.h
  group SRC/lc_iot
    ../../src/lc_iot/sta/ble_net/: ble_api.c ble_api.h ble_apl.c ble_apl.h ble_data.c ble_data.h ble_event.c ble_event.h ble_local.c ble_local.h ble_mac.c ble_mac.h ble_net.c ble_net.h ble_update.c ble_update.h lamp_date.c lamp_date.h
  group SRC/lc_iot/lc_diff
    ../../src/lcdiff/: bspatch.c bspatch.h lcdiff_update.c lcdiff_update.h tuz_dec.c tuz_dec.h tuz_types.h tuz_types_private.h
  group SRC/net
    ../../src/net/src/: hplc_app.c hplc_storage.c hplc_task.c hplc_update.c
    ../../: mac_zb205.a
  group SRC/net/inc
    ../../src/net/inc/: hplc_app.h hplc_app_def.h hplc_beacon.h hplc_channel_status.h hplc_data.h hplc_frame.h hplc_mac.h hplc_mac_def.h hplc_mpdu.h hplc_NID.h hplc_offline.h hplc_protocol_init.h hplc_route_period.h hplc_send.h hplc_task.h hplc_test_model.h hplc_timer.h hplc_TMI.h hplc_update.h hplc_zc_manager.h hplc_zone.h
  group SRC/phy
    ../../src/phy/: phy_task.c
    ../../: phy_zb205.a
  group uC/CPU
    ../../ucosIII/uC-CPU/: cpu_core.c
  group uC/CPU/ARM-Cortex-M4/IAR
    ../../ucosIII/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
  group uC/LIB
    ../../ucosIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group uC/LIB/Ports/ARM-Cortex-M4/IAR
    ../../ucosIII/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group uC/OS-III/Ports/ARM-Cortex-M4/Generic/IAR
    ../../ucosIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
  group uC/OS-III/Source
    ../../ucosIII/uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_type.h os_var.c
